## config/boards/shields/tester_pro_micro/Kconfig.shield
```kconfig
config SHIELD_tester_pro_micro
    def_bool $(shields_list_contains,tester_pro_micro)
```
